/* SPDX-License-Identifier: GPL-3.0-only */
#include "zdt_frame.h"

#include <string.h>

/* 手册 8.1 的 crc8Table，即 Dallas/Maxim CRC-8（反射多项式 0x8C） */
static const uint8_t kCrc8Table[256] = {
    0x00, 0x5E, 0xBC, 0xE2, 0x61, 0x3F, 0xDD, 0x83, 0xC2, 0x9C, 0x7E, 0x20, 0xA3, 0xFD, 0x1F, 0x41,
    0x9D, 0xC3, 0x21, 0x7F, 0xFC, 0xA2, 0x40, 0x1E, 0x5F, 0x01, 0xE3, 0xBD, 0x3E, 0x60, 0x82, 0xDC,
    0x23, 0x7D, 0x9F, 0xC1, 0x42, 0x1C, 0xFE, 0xA0, 0xE1, 0xBF, 0x5D, 0x03, 0x80, 0xDE, 0x3C, 0x62,
    0xBE, 0xE0, 0x02, 0x5C, 0xDF, 0x81, 0x63, 0x3D, 0x7C, 0x22, 0xC0, 0x9E, 0x1D, 0x43, 0xA1, 0xFF,
    0x46, 0x18, 0xFA, 0xA4, 0x27, 0x79, 0x9B, 0xC5, 0x84, 0xDA, 0x38, 0x66, 0xE5, 0xBB, 0x59, 0x07,
    0xDB, 0x85, 0x67, 0x39, 0xBA, 0xE4, 0x06, 0x58, 0x19, 0x47, 0xA5, 0xFB, 0x78, 0x26, 0xC4, 0x9A,
    0x65, 0x3B, 0xD9, 0x87, 0x04, 0x5A, 0xB8, 0xE6, 0xA7, 0xF9, 0x1B, 0x45, 0xC6, 0x98, 0x7A, 0x24,
    0xF8, 0xA6, 0x44, 0x1A, 0x99, 0xC7, 0x25, 0x7B, 0x3A, 0x64, 0x86, 0xD8, 0x5B, 0x05, 0xE7, 0xB9,
    0x8C, 0xD2, 0x30, 0x6E, 0xED, 0xB3, 0x51, 0x0F, 0x4E, 0x10, 0xF2, 0xAC, 0x2F, 0x71, 0x93, 0xCD,
    0x11, 0x4F, 0xAD, 0xF3, 0x70, 0x2E, 0xCC, 0x92, 0xD3, 0x8D, 0x6F, 0x31, 0xB2, 0xEC, 0x0E, 0x50,
    0xAF, 0xF1, 0x13, 0x4D, 0xCE, 0x90, 0x72, 0x2C, 0x6D, 0x33, 0xD1, 0x8F, 0x0C, 0x52, 0xB0, 0xEE,
    0x32, 0x6C, 0x8E, 0xD0, 0x53, 0x0D, 0xEF, 0xB1, 0xF0, 0xAE, 0x4C, 0x12, 0x91, 0xCF, 0x2D, 0x73,
    0xCA, 0x94, 0x76, 0x28, 0xAB, 0xF5, 0x17, 0x49, 0x08, 0x56, 0xB4, 0xEA, 0x69, 0x37, 0xD5, 0x8B,
    0x57, 0x09, 0xEB, 0xB5, 0x36, 0x68, 0x8A, 0xD4, 0x95, 0xCB, 0x29, 0x77, 0xF4, 0xAA, 0x48, 0x16,
    0xE9, 0xB7, 0x55, 0x0B, 0x88, 0xD6, 0x34, 0x6A, 0x2B, 0x75, 0x97, 0xC9, 0x4A, 0x14, 0xF6, 0xA8,
    0x74, 0x2A, 0xC8, 0x96, 0x15, 0x4B, 0xA9, 0xF7, 0xB6, 0xE8, 0x0A, 0x54, 0xD7, 0x89, 0x6B, 0x35,
};

uint8_t zdt_checksum_calc(zdt_checksum_t mode, const uint8_t *data, size_t len)
{
    switch (mode) {
    case ZDT_CHECKSUM_XOR: {
        uint8_t x = 0;
        for (size_t i = 0; i < len; ++i) x ^= data[i];
        return x;
    }
    case ZDT_CHECKSUM_CRC8: {
        /* 照搬手册 cmd_calCRC8：初值为首字节本身（不先查表），从第 2 字节起查表 */
        if (len == 0) return 0;
        uint8_t crc = data[0];
        for (size_t i = 1; i < len; ++i) crc = kCrc8Table[crc ^ data[i]];
        return crc;
    }
    case ZDT_CHECKSUM_FIXED_6B:
    default:
        return ZDT_CHECKSUM_DEFAULT;
    }
}

int zdt_frame_set_checksum(uint8_t *frame, size_t len, zdt_checksum_t mode)
{
    if (!frame || len < 2) return ZDT_ERR_PARAM;
    frame[len - 1] = zdt_checksum_calc(mode, frame, len - 1);
    return ZDT_OK;
}

size_t zdt_ttl_reply_len(uint8_t code, zdt_firmware_t fw)
{
    switch (code) {
    case 0x42: case 0x43:   /* 第 3 字节为整帧长度 */
        return 0;
    case 0x21: return fw == ZDT_FW_X ? 19 : 15;     /* PID：X 4 个 u32，Emm 3 个 u32 */
    case 0x22: return 18;   /* 回零参数 */
    case 0x49: return 17;   /* DMX512 参数 */
    case 0x13: return 9;    /* 过热过流阈值 */
    case 0x32: case 0x33: case 0x34: case 0x36: case 0x37:
        return 8;           /* 符号 + u32 */
    case 0x16: case 0x1F: case 0x20: case 0x23:
        return 7;
    case 0x35: return 6;    /* 转速：符号 + u16 */
    case 0x1A:              /* 选项状态：手册画 1 字节，真机为 u16（bit8-9 为参数锁等级） */
    case 0x24: case 0x26: case 0x27: case 0x31: case 0x38: case 0x39:
    case 0x3C: case 0x3F: case 0x41:
        return 5;
    default:                /* 状态应答、3A / 3B / 3D 单字节读取、11 定时返回的启停确认 */
        return 4;
    }
}

int zdt_ttl_parse(const uint8_t *buf, size_t len, zdt_checksum_t mode, zdt_firmware_t fw,
                  zdt_reply_t *out)
{
    if (!buf || !out) return ZDT_ERR_PARAM;
    if (len < 1) return 0;
    if (buf[0] == ZDT_ADDR_BROADCAST) return ZDT_ERR_FRAME;   /* 应答总带电机自己的地址 */
    if (len < 2) return 0;

    size_t need;
    if (buf[1] == 0x00) {
        need = 4;                                   /* Addr 00 EE 校验 */
    } else {
        need = zdt_ttl_reply_len(buf[1], fw);
        if (need == 0) {
            if (len < 3) return 0;
            need = buf[2];
        }
    }
    if (need < 4 || need > ZDT_TTL_MAX_FRAME) return ZDT_ERR_FRAME;
    if (len < need) return 0;

    if (buf[need - 1] != zdt_checksum_calc(mode, buf, need - 1)) return ZDT_ERR_FRAME;
    if (buf[1] == 0x00 && buf[2] != ZDT_REPLY_FORMAT_ERR) return ZDT_ERR_FRAME;

    out->addr = buf[0];
    out->code = buf[1];
    out->len = (uint8_t)(need - 3);
    memcpy(out->data, buf + 2, need - 3);
    out->checksum = buf[need - 1];
    return (int)need;
}
